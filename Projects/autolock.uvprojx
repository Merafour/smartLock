# Keil uVision project autolock.uvprojx, settings and files
target Autolock (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: autolock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030,USE_STDPERIPH_DRIVER,HSE_VALUE=16000000
  c include: ..\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\User\main;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\User\drive\mcu;.\User\drive\peripheral;.\User\logic\cpp;.\User\logic\menu;.\User\logic\misc;.\User\logic\math;.\User\logic\interface;.\User\logic\draw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Libraries
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ./User/main/: delay.c stm32f0xx_it.c system_stm32f0xx.c main.cpp
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group CPP
    ./User/logic/menu/: menu.cpp menu_admin.cpp menu_level.cpp menu_level3.cpp
    ./User/logic/interface/: hardware.cpp object.cpp safety.cpp
    ./User/logic/math/: dhcp_check.cpp Subfunc.cpp
  group readme
    ../: readme.txt 语音.txt
  group Misc
    ./User/logic/misc/: data.cpp data_flash.cpp input_manage.cpp
  group Drive
    ./User/drive/mcu/: power.c RTC.c stm32_i2c.c eeprom.c uart.c uartDMA.c
    ./User/drive/peripheral/: fingerprint.cpp model.cpp wtn6.cpp rgbw.cpp ssd1306syp.cpp BS8116A-3.c rfid.cpp
  group draw
    ./User/logic/draw/: Draw.cpp ftoa_engine.cpp mprint.cpp utoa_invert.cpp gb2312.c
